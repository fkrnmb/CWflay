# Keil uVision project Flay.uvprojx, settings and files
target Target_1 (6220000::V6.22::ARMCLANG)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: Flay
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=6 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx,ARM_MATH_CM4
  c include: .\CMSIS\include;.\HAL\Inc;.\HAL\Inc\Legacy;.\Main;.\system;.\Device\cherryUSB\port\dwc2;.\Device\cherryUSB\core;.\Device\cherryUSB\common;.\Device\cherryUSB\class\cdc;.\Device\cherryUSB;.\Device;.\Device\cherryUSB\class\hub;.\Device\cherryUSB\class\msc;.\Device\cherryUSB\class\hid;.\FreeRTOS\include;.\FreeRTOS\portable\RVDS\ARM_CM4F;.\FreeRTOS\portable\MemMang;.\FreeRTOS\examples\template_configuration;.\MinSensor;.\Device\cherryUSB\class\msc;.\Device\ff16\source;.\Communication\MAVLINK\common;.\Communication\MAVLINK;.\Communication;.\Fliter
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Main
    ./Main/: Main.cpp
  group CMSIS
    ./CMSIS/src/: startup_stm32f407xx.s system_stm32f4xx.c
  group system
    ./system/: system.cpp Time.cpp
  group HAL
    ./HAL/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_spi.c
  group FreeRTOS
    ./FreeRtos/src/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ./FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ./FreeRTOS/portable/MemMang/: heap_4.c
  group Drivers
    ./Device/: drv_USB.cpp drv_SPI.cpp ExtFlash.cpp drv_FLASH.cpp Uart1.cpp Uart2.cpp drv_LED.cpp drv_IIC.cpp Debug.cpp drv_FatFs.cpp
  group MianSonser
    ./MinSensor/: IMU.cpp HeaDingSensor.cpp
  group Filter
    ./Fliter/: ButterWorth.cpp
  group USB
    ./Device/cherryUSB/osal/: usb_osal_freertos.c
    ./Device/cherryUSB/class/cdc/: usbd_cdc_acm.c
    ./Device/cherryUSB/core/: usbd_core.c
    ./Device/cherryUSB/port/dwc2/: usb_glue_st.c usb_dc_dwc2.c
    ./Device/cherryUSB/demo/: cdc_acm_msc_template.c
    ./Device/cherryUSB/class/msc/: usbd_msc.c
  group FatFs
    ./Device/ff16/source/: diskio.c ff.c ffsystem.c ffunicode.c
  group Communication
    ./Communication/: Communication.cpp
